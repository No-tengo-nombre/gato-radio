options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: gato_receiver
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    label: Audio Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.1'
    stop: '100'
    value: '1'
  states: {}
- name: channel_freq
  id: variable_qtgui_range
  parameters:
    label: Channel frequency
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '50000000'
    step: '100000'
    stop: '150000000'
    value: '93300000'
  states: {}
- name: lp_cutoff
  id: variable_qtgui_range
  parameters:
    label: Low pass cutoff
    outputmsgname: value
    showports: 'False'
    start: 1e3
    step: 1e3
    stop: 300e3
    value: 75e3
  states: {}
- name: lp_decimation
  id: variable_qtgui_range
  parameters:
    label: Low pass decimation
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '1'
    step: '1'
    stop: '50'
    value: '12'
  states: {}
- name: lp_width
  id: variable_qtgui_range
  parameters:
    label: Low pass width
    outputmsgname: value
    showports: 'False'
    start: 1e3
    step: 1e3
    stop: 300e3
    value: 25e3
  states: {}
- name: quadrature
  id: variable_qtgui_range
  parameters:
    label: Quadrature
    outputmsgname: value
    showports: 'False'
    start: 1e3
    step: 1e3
    stop: 500e3
    value: 250e3
  states: {}
- name: resampler_decimation
  id: variable_qtgui_range
  parameters:
    label: Resampler decimation
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '1'
    step: '1'
    stop: '50'
    value: '5'
  states: {}
- name: resampler_interp
  id: variable_qtgui_range
  parameters:
    label: Resampler interpolation
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '1'
    step: '1'
    stop: '50'
    value: '12'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2560000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: channel_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: quadrature
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lp_cutoff
    decim: int(samp_rate / quadrature)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: lp_width
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: channel_freq
    fftsize: '1024'
    name: '"SDR source"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: channel_freq
    fftsize: '1024'
    name: '"Filtered entrance"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: resampler_decimation
    interp: resampler_interp
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(quadrature / 1e3)
    interp: '48'
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(quadrature)
    interp: int(48e3)
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: channel_freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', blocks_multiply_xx_0, '1']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
