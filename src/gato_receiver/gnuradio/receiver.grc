options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: gato_receiver
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    label: Carrier Frecuency
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100000'
    value: '10'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: signal_bandwidth
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: variable_qtgui_range_1
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: variable_qtgui_range_2
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '8'
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: '384000'
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', audio_sink_0, '0']
- [rtlsdr_source_0, '0', analog_fm_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
