options:
  parameters:
    generate_options: qt_gui
    id: gato_receiver_tcp
    output_language: python
    title: gato_receiver
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    label: Audio Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.1'
    stop: '100'
    value: '1'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: channel_freq
  id: variable_qtgui_range
  parameters:
    label: Channel frequency
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '50000000'
    step: '100000'
    stop: '150000000'
    value: '93300000'
  states: {}
- name: lp_cutoff
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: lp_width
  id: variable
  parameters:
    value: 25e3
  states: {}
- name: quadrature
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2560000'
  states: {}
- name: tcp_port
  id: variable
  parameters:
    value: '42069'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: quadrature
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lp_cutoff
    decim: int(samp_rate / quadrature)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: lp_width
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: tcp_port
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: channel_freq
    fftsize: '1024'
    name: '"SDR source"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: channel_freq
    fftsize: '1024'
    name: '"Filtered entrance"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(quadrature)
    interp: int(audio_samp_rate)
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: channel_freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', network_tcp_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
