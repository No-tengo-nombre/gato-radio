options:
  parameters:
    generate_options: qt_gui
    id: radio_transmitter
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ganancia
  id: variable_qtgui_range
  parameters:
    label: ganancia
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: noise
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(44.1e3)
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: ganancia
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\Bruno\Downloads\Eres-Tan-Fea...Pero-Te-Quiero.wav
    repeat: 'True'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    bw0: 2e5
    freq0: 93.1e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate*100
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '100'
    type: ccc
  states: {}

connections:
- [analog_wfm_tx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', analog_wfm_tx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1, '0', osmosdr_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_add_xx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
